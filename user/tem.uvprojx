# Keil uVision project tem.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tem +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\fwlib\inc;..\CORE;..\user;..\driver;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\driver\fans;..\driver\breath_led;..\driver\exti;..\driver\pm2_5;..\driver\led;..\driver\zigbee;..\driver\buzzer;..\driver\dht11;..\driver\voc;..\driver\power_output;..\driver\tilt
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_tim.c
  group core
    ../CORE/: startup_stm32f40_41xxx.s
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group driver
    ../driver/fans/: fans.c
    ../driver/breath_led/: breath_led.c
    ../driver/exti/: key.c
    ../driver/pm2_5/: pm2_5.c
    ../driver/led/: led.c
    ../driver/zigbee/: zigbee.c
    ../driver/buzzer/: buzzer.c
    ../driver/dht11/: dht11.c
    ../driver/voc/: voc.c
    ../driver/power_output/: power_output.c
    ../driver/tilt/: tilt.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
